# IAR project cell_tests.ewp, settings and files
configuration Flash (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: LPC2378 NXP LPC2378
  ICCARM.CCDefines: IAR_LPC_2378_SK
  ICCARM.CCIncludePath2: $TOOLKIT_DIR$\INC\NXP; include\app; include\os; ..\..\bsp\include; ..\..\cell\include; ..\..\Micrium\Software\ucos-ii\ports\arm\generic\iar; ..\..\Micrium\Software\ucos-ii\source; ..\..\Micrium\Software\uc-lib; ..\..\Micrium\Software\uc-cpu; ..\..\Micrium\Software\uc-cpu\arm\IAR
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  OBJCOPY.OOCOutputFile: a.srec
  ILINK.IlinkOutputFile: a.out
  ILINK.IlinkIcfFile: config\LPC2378_Flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group bsp
    ../../bsp/src/: accelerometer.c adc.c bsp.c buttons.c can.c delay.c lcd.c leds.c potentiometer.c pwm.c timers.c
  group bsp/lcd
    ../../bsp/src/lcd/: drv_glcd.c glcd_ll.c
  group bsp/lcd/fonts
    ../../bsp/src/lcd/fonts/: Terminal_9_12x6.c
  group cell
    ../../cell/src/: control.c conveyor.c interface.c robot.c
  group Micrium/uC/CPU
    ../../Micrium/Software/uC-CPU/ARM/IAR/: cpu.h cpu_a.s
    ../../Micrium/Software/uC-CPU/: cpu_def.h
  group Micrium/uC/LIB
    ../../Micrium/Software/uC-LIB/: lib_def.h lib_mem.c lib_mem.h lib_str.c lib_str.h
  group Micrium/uC/OS-II/Port
    ../../Micrium/Software/uCOS-II/Ports/ARM/Generic/IAR/: os_cpu.h os_cpu_a.asm os_cpu_c.c os_dbg.c os_dcc.c
  group Micrium/uC/OS-II/Source
    ../../Micrium/Software/uCOS-II/Source/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c ucos_ii.h
  group project/include/app
    include/app/: buffer.h
  group project/include/os
    include/os/: os_cfg.h osutils.h
  group project/src/app
    src/app/: buffer.c main.c
  group project/src/os
    src/os/: cstartup.s osutils.c
